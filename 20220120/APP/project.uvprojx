# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 485fw +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\Include;.\CMSIS;.\FATFS;.\STM32F4xx_StdPeriph_Driver\inc;.\USER;.\USER\led;.\USER\debug_uart;.\USER\rtc;.\USER\sd_card;.\USER\rs485;.\USER\scanner;.\USER\4G;.\USER\wifi;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\USER\rs232;.\USER\cjson;.\USER\base64;.\USER\io
  memory RVCT4: ROM 0x8008000 size 0x58000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\app.sct
  group cmsis
    ./CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group user
    ./USER/: my_print.h main.c crc16.c crc16.h my_tasks.h network_status_Task.c offline_data_process_Task.c firmware_transmit_Task.c server_data_process_Task.c sensor_data_transmit_Task.c makedata.c makedata.h
    ./USER/debug_uart/: debug_uart.c debug_uart.h
    ./USER/rtc/: rtc.c rtc.h
    ./USER/led/: led.c led.h
    ./USER/4G/: 4G.c 4G.h
    ./USER/sd_card/: sd_sdio.c sd_sdio.h sd_operation.c sd_operation.h
    ./USER/wifi/: wifi.c wifi.h
    ./USER/rs485/: rs485.c rs485.h
    ./USER/rs232/: rs232.c rs232.h
    ./USER/cjson/: cJSON.c cJSON.h
    ./USER/base64/: base64.c base64.h
    ./USER/scanner/: scanner.c scanner.h
    ./USER/io/: io.c io.h
  group lib
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_flash.c
  group fatfs
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group freerots
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
