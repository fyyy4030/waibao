# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\CMSIS\Include;.\CMSIS;.\FATFS;.\STM32F4xx_StdPeriph_Driver\inc;.\USER;.\USER\led;.\USER\debug_uart;.\USER\rtc;.\USER\sd_card;.\USER\rs485;.\USER\scanner;.\USER\4G;.\USER\cjson
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\boot.sct
  group cmsis
    ./CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group user
    ./USER/: main.c jumpapp.c
    ./USER/debug_uart/: debug_uart.c debug_uart.h
    ./USER/sd_card/: sd_sdio.c sd_sdio.h
    ./USER/cjson/: cJSON.c cJSON.h
    ./USER/led/: led.c
  group lib
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_sdio.c stm32f4xx_dma.c
  group fatfs
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
